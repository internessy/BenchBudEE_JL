File: BenchBudEE.kicad_pcb (KiCad board)
At the start: 2 copper layers, 0 parts

Commit message: before layout
Parts:
- added 3M-N7E50: VAL**, connect:3M-N7E50, F.Cu at (174.0, 101.6)
